# IAR project spotmgr_profiler.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AP510NFA-CBR AmbiqMicro AP510NFA-CBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 64
  General.FPU2: 7
  ICCARM.CCDefines: iar; AM_PACKAGE_BGA; AM_PART_APOLLO510; AM_PRINTF_BUFSIZE=256
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\bsp; ..\..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\..\mcu\apollo510; ..\..\..\..\..\..\devices; ..\..\..\..\..\..; ..\..\..\..\..\..\utils; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: spotmgr_profiler.bin
  ILINK.IlinkOutputFile: spotmgr_profiler.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\mcu\apollo510\hal\mcu\iar\bin\libam_hal.a; ..\..\..\..\bsp\iar\bin\libam_bsp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.FPU2: 1
  ICCARM.CCDefines: NDEBUG; iar; AM_PACKAGE_BGA; AM_PART_APOLLO510; AM_PRINTF_BUFSIZE=256
  group (top)
    ../src/: am_resources.c spotmgr_profiler.c
    ../../../../../../utils/: am_util_delay.c am_util_stdio.c
    ./: startup_iar.c
