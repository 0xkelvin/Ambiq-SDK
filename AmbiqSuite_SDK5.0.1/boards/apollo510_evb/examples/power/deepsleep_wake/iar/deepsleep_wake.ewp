# IAR project deepsleep_wake.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AP510NFA-CBR AmbiqMicro AP510NFA-CBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 64
  General.FPU2: 7
  ICCARM.CCDefines: iar; AM_PACKAGE_BGA; AM_PART_APOLLO510; AM_PRINTF_BUFSIZE=256
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\bsp; ..\..\..\..\..\..\devices; ..\..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\..; ..\..\..\..\..\..\utils; ..\src; ..\..\..\..\..\..\mcu\apollo510; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: deepsleep_wake.bin
  ILINK.IlinkOutputFile: deepsleep_wake.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\..\mcu\apollo510\hal\mcu\iar\bin\libam_hal.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.FPU2: 1
  ICCARM.CCDefines: NDEBUG; iar; AM_PACKAGE_BGA; AM_PART_APOLLO510; AM_PRINTF_BUFSIZE=256
  group (top)
    ../src/: am_resources.c deepsleep_wake.c
    ../../../../../../devices/: am_devices_led.c
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c am_util_string.c am_util_time.c
    ./: startup_iar.c
