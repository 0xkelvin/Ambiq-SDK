# IAR project coremark_best_cm_per_mJ.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AP510NFA-CBR AmbiqMicro AP510NFA-CBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 64
  General.FPU2: 7
  ICCARM.CCDefines: iar; COREMARK_BEST_CM_PER_mJ; AM_PART_APOLLO510; COREMARK; AM_PRINTF_BUFSIZE=5120; AM_PACKAGE_BGA
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\..; ..\..\..\..\..\..\devices; ..\..\..\..\..\..\mcu\apollo510; ..\..\..\..\..\..\utils; ..\src; ..\..\..\..\bsp; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: coremark_best_cm_per_mJ.bin
  ILINK.IlinkOutputFile: coremark_best_cm_per_mJ.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\mcu\apollo510\hal\mcu\iar\bin\libam_hal.a; ..\..\..\..\bsp\iar\bin\libam_bsp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.FPU2: 1
  ICCARM.CCDefines: NDEBUG; iar; COREMARK_BEST_CM_PER_mJ; AM_PART_APOLLO510; COREMARK; AM_PRINTF_BUFSIZE=5120; AM_PACKAGE_BGA
  group (top)
    ../src/: am_resources.c am_time.c coremark_best_cm_per_mJ.c core_list_join.c core_main.c core_matrix.c core_portme.c core_state.c core_util.c
    ../../../../../../utils/: am_util_delay.c am_util_pp.c am_util_stdio.c
    ../../../../../../devices/: am_devices_led.c
    ./: startup_iar.c
