# Keil uVision project coremark_best_performance.uvprojx, settings and files
target coremark_best_performance (6220000::V6.22::ARMCLANG)
  device: AP510NFA-CBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.5.0
  cpu: IRAM(0x00000000,0x00040000) IRAM2(0x20000000,0x00080000) IROM(0x00400000,0x00400000) XRAM(0x20080000,0x00300000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP CLOCK(12000000) ELITTLE
  output: coremark_best_performance
  AfterMake: fromelf --bin --output bin\coremark_best_performance.bin bin\coremark_best_performance.axf
  c flags: Optim=8 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: COREMARK AM_PACKAGE_BGA AM_PRINTF_BUFSIZE=5120 AM_PART_APOLLO510 COREMARK_BEST_PERFORMANCE keil6
  c include: ../../../../bsp;../../../../../..;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../devices;../../../../../../mcu/apollo510;../../../../../../CMSIS/ARM/Include;../src;../../../../../../utils
  memory RVCT4: ROM 0x400000 size 0x400000
  memory RVCT6: RAM 0x20080000 size 0x300000
  memory RVCT9: RAM 0x0 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x80000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo510/hal/mcu/keil6/bin/libam_hal.lib --undefined=__scatterload_copy --lto -Omax
  group src
    ../src/: am_resources.c am_time.c coremark_best_performance.c core_list_join.c core_main.c core_matrix.c core_portme.c core_state.c core_util.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_pp.c am_util_stdio.c
  group devices
    ../../../../../../devices/: am_devices_led.c
  group keil6
    ../keil6/: startup_keil6.c
  group lib
    ../../../../bsp/keil6/bin/: libam_bsp.lib
    ../../../../../../mcu/apollo510/hal/mcu/keil6/bin/: libam_hal.lib
software components: Device:Startup 1.1.0
