# Keil uVision project audadc_rtt_stream.uvprojx, settings and files
target audadc_rtt_stream (6220000::V6.22::ARMCLANG)
  device: AP510NFA-CBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.5.0
  cpu: IRAM(0x00000000,0x00040000) IRAM2(0x20000000,0x00080000) IROM(0x00400000,0x00400000) XRAM(0x20080000,0x00300000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP CLOCK(12000000) ELITTLE
  output: audadc_rtt_stream
  AfterMake: fromelf --bin --output bin\audadc_rtt_stream.bin bin\audadc_rtt_stream.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __FPU_PRESENT AM_UTIL_FAULTISR_PRINT SEGGER_RTT_SECTION=\"SHARED_RW\" AM_PACKAGE_BGA AM_PART_APOLLO510 keil6
  c include: ../../../../../../CMSIS/ARM/Include;../../../../../../third_party/SEGGER/RTT/RTT;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../..;../../../../bsp;../../../../../../mcu/apollo510;../../../../../../utils;../../../../../../devices;../src;../../../../../../third_party/SEGGER/RTT/Config
  memory RVCT4: ROM 0x400000 size 0x400000
  memory RVCT6: RAM 0x20080000 size 0x300000
  memory RVCT9: RAM 0x0 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x80000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo510/hal/mcu/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group src
    ../src/: am_resources.c audadc_rtt_stream.c
  group SEGGER_RTT
    ../../../../../../third_party/SEGGER/RTT/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group devices
    ../../../../../../devices/: am_devices_led.c
  group keil6
    ../keil6/: startup_keil6.c
  group lib
    ../../../../bsp/keil6/bin/: libam_bsp.lib
    ../../../../../../mcu/apollo510/hal/mcu/keil6/bin/: libam_hal.lib
software components: Device:Startup 1.1.0
