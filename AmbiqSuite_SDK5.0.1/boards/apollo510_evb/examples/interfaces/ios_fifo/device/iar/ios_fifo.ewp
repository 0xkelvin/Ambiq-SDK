# IAR project ios_fifo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AP510NFA-CBR AmbiqMicro AP510NFA-CBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 64
  General.FPU2: 7
  ICCARM.CCDefines: iar; AM_PART_APOLLO510; AM_PACKAGE_BGA
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\utils; ..\..\common; ..\..\..\..\..\..\..; ..\..\..\..\..\..\..\boards\apollo510_evb\bsp; ..\..\..\..\..\..\..\devices; ..\..\..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\src; ..\..\..\..\..\..\..\mcu\apollo510
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ios_fifo.bin
  ILINK.IlinkOutputFile: ios_fifo.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\..\boards\apollo510_evb\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\..\..\mcu\apollo510\hal\mcu\iar\bin\libam_hal.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.FPU2: 1
  ICCARM.CCDefines: NDEBUG; iar; AM_PART_APOLLO510; AM_PACKAGE_BGA
  group (top)
    ../../common/: ios_fifo_common.c
    ../src/: am_resources.c ios_fifo.c
    ../../../../../../../utils/: am_util_delay.c am_util_stdio.c
    ./: startup_iar.c
