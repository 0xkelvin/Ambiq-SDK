# IAR project uart_fullduplex.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AP510NFA-CBR AmbiqMicro AP510NFA-CBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 64
  General.FPU2: 7
  ICCARM.CCDefines: iar; AM_PART_APOLLO510; AM_PACKAGE_BGA
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\devices; ..\..\..\..\..\..\..\mcu\apollo510; ..\..\..\..\..\..\..\utils; ..\..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\..\..; ..\..\common; ..\..\..\..\..\..\..\boards\apollo510_evb\bsp; ..\src; ..\..\..\..\..\..\..\CMSIS\ARM\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: uart_fullduplex.bin
  ILINK.IlinkOutputFile: uart_fullduplex.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\..\boards\apollo510_evb\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\..\..\mcu\apollo510\hal\mcu\iar\bin\libam_hal.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.FPU2: 1
  ICCARM.CCDefines: NDEBUG; iar; AM_PART_APOLLO510; AM_PACKAGE_BGA
  group (top)
    ../../common/: handshake_gpio.c mpu_config.c uart_example_timer_control.c uart_fullduplex_common.c uart_streaming_utils.c
    ../src/: am_resources.c uart_fullduplex.c
    ../../../../../../../utils/: am_util_delay.c am_util_stdio.c
    ./: startup_iar.c
