# Keil uVision project uart_stream_echo_txDma.uvprojx, settings and files
target uart_stream_echo_txDma (6220000::V6.22::ARMCLANG)
  device: AP510NFA-CBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.5.0
  cpu: IRAM(0x00000000,0x00040000) IRAM2(0x20000000,0x00080000) IROM(0x00400000,0x00400000) XRAM(0x20080000,0x00300000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP CLOCK(12000000) ELITTLE
  output: uart_stream_echo_txDma
  AfterMake: fromelf --bin --output bin\uart_stream_echo_txDma.bin bin\uart_stream_echo_txDma.axf
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AM_PART_APOLLO510 AM_PACKAGE_BGA keil6
  c include: ../../../../bsp;../../../../../..;../../../../../../devices;../../../../../../mcu/apollo510/hal;../../../../../../mcu/apollo510;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../utils;../../../../../../CMSIS/ARM/Include;../src
  memory RVCT4: ROM 0x400000 size 0x400000
  memory RVCT6: RAM 0x20080000 size 0x300000
  memory RVCT9: RAM 0x0 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x80000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo510/hal/mcu/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group src
    ../src/: am_resources.c uart_example_timer_control.c uart_stream_common.c uart_stream_echo_txDma.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_id.c am_util_stdio.c am_util_string.c
  group keil6
    ../keil6/: startup_keil6.c
  group lib
    ../../../../bsp/keil6/bin/: libam_bsp.lib
    ../../../../../../mcu/apollo510/hal/mcu/keil6/bin/: libam_hal.lib
software components: Device:Startup 1.1.0
