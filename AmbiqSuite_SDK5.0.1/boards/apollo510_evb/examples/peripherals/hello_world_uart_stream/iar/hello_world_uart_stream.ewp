# IAR project hello_world_uart_stream.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AP510NFA-CBR AmbiqMicro AP510NFA-CBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 64
  General.FPU2: 7
  ICCARM.CCDefines: iar; AM_PART_APOLLO510; AM_PACKAGE_BGA
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\src; ..\..\..\..\..\..\devices; ..\..\..\..\..\..; ..\..\..\..\..\..\mcu\apollo510; ..\..\..\..\..\..\utils; ..\..\..\..\bsp; ..\..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: hello_world_uart_stream.bin
  ILINK.IlinkOutputFile: hello_world_uart_stream.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\mcu\apollo510\hal\mcu\iar\bin\libam_hal.a; ..\..\..\..\bsp\iar\bin\libam_bsp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.FPU2: 1
  ICCARM.CCDefines: NDEBUG; iar; AM_PART_APOLLO510; AM_PACKAGE_BGA
  group (top)
    ../src/: am_resources.c hello_world_uart_stream.c
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_id.c am_util_stdio.c am_util_string.c
    ./: startup_iar.c
