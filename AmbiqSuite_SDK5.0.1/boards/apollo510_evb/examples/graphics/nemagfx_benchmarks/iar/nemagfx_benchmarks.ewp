# IAR project nemagfx_benchmarks.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AP510NFA-CBR AmbiqMicro AP510NFA-CBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 64
  General.FPU2: 7
  ICCARM.CCDefines: iar; AM_PART_APOLLO510; NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK; NEMA_PLATFORM=apollo510_nemagfx; AM_PACKAGE_BGA; BAREMETAL; CPU_SLEEP; LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib; GPU_BURST_MODE
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\NemaGFX\Nema; ..\src; ..\..\..\..\..\..\utils; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\NemaGFX; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\common; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\common\mem; ..\..\..\..\..\..; ..\..\..\..\..\..\mcu\apollo510\hal\mcu; ..\..\..\..\..\..\mcu\apollo510\hal; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\NemaDC; ..\..\..\..\..\..\mcu\apollo510; ..\..\..\..\..\..\devices; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\NemaGFX; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\NemaVG; ..\..\..\..\..\..\third_party\ThinkSi\config\apollo510_nemagfx; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\NemaDC; ..\..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\bsp
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: nemagfx_benchmarks.bin
  ILINK.IlinkOutputFile: nemagfx_benchmarks.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\..\mcu\apollo510\hal\mcu\iar\bin\libam_hal.a; ..\..\..\..\..\..\third_party\ThinkSi\config\apollo510_nemagfx\iar\bin\lib_nema_apollo510_nemagfx.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.FPU2: 1
  ICCARM.CCDefines: NDEBUG; iar; AM_PART_APOLLO510; NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK; NEMA_PLATFORM=apollo510_nemagfx; AM_PACKAGE_BGA; BAREMETAL; CPU_SLEEP; LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib; GPU_BURST_MODE
  group (top)
    ../../../../../../third_party/ThinkSi/config/apollo510_nemagfx/: nema_dc_hal.c nema_event.c nema_hal.c nema_utils.c
    ../src/: am_resources.c bench_blit.c bench_draw_circle.c bench_draw_line.c bench_draw_rect.c bench_draw_string.c bench_fill_quad.c bench_fill_rect.c bench_fill_tri.c bench_stretch_blit.c bench_stretch_blit_rotate.c bench_textured_quad.c bench_textured_tri.c DejaVuSerif12pt8b.c nemagfx_benchmarks.c utils.c
    ../../../../../../utils/: am_util_delay.c am_util_stdio.c
    ../../../../../../devices/: am_devices_display_generic.c
    ./: startup_iar.c
