# Keil uVision project lvgl_watch_demo_simplified.uvprojx, settings and files
target lvgl_watch_demo_simplified (6220000::V6.22::ARMCLANG)
  device: AP510NFA-CBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.5.0
  cpu: IRAM(0x00000000,0x00040000) IRAM2(0x20000000,0x00080000) IROM(0x00400000,0x00400000) XRAM(0x20080000,0x00300000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP CLOCK(12000000) ELITTLE
  output: lvgl_watch_demo_simplified
  AfterMake: fromelf --bin --output bin\lvgl_watch_demo_simplified.bin bin\lvgl_watch_demo_simplified.axf
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: LV_AMBIQ_FB_USE_RGB888=1 AM_PACKAGE_BGA LV_CONF_INCLUDE_SIMPLE LV_AMBIQ_FB_RESX=456 AM_PART_APOLLO510 LV_AMBIQ_FB_RESY=456 LV_AMBIQ_FB_USE_RGB565=0 WAIT_IRQ_BINARY_SEMAPHORE=1 NEMA_CUSTOM_MALLOC_INCLUDE=\"lv_ambiq_nema_hal.h\" NEMA_USE_CUSTOM_MALLOC AM_UTIL_FAULTISR_PRINT apollo510_evb NEMA_GFX_POWERSAVE LV_LVGL_H_INCLUDE_SIMPLE AM_FREERTOS LV_AMBIQ_FB_REFRESH_TWO NEMA_PLATFORM=apollo510_nemagfx NEMA_GFX_POWEROFF_END_CL MSPI_PSRAM_TIMING_CHECK LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK keil6
  c include: ../../../../../../third_party/FreeRTOSv10.5.1/Source/include;../../../../../../third_party/LVGL/lvgl/src;../../../../bsp;../../../../../../devices;../../../../../../third_party/LVGL/lvgl/src/gpu;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaDC;../../../../../../mcu/apollo510/hal;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/common;../../../../../../third_party/ThinkSi/NemaGFX_SDK/NemaGFX/Nema;../../../../../../third_party/ThinkSi/NemaGFX_SDK/NemaDC;../src;../../../../../../utils;../../../../../../third_party/ThinkSi/NemaGFX_SDK/common/mem;../../../../../../third_party/ThinkSi/config/apollo510_nemagfx;../../../../../..;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaGFX;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../third_party/LVGL/ambiq_support;../../../../../../CMSIS/ARM/Include;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaVG;../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/Keil6/AMapollo5;../../../../../../mcu/apollo510;../../../../../../third_party/ThinkSi/NemaGFX_SDK/NemaGFX
  memory RVCT4: ROM 0x400000 size 0x400000
  memory RVCT6: RAM 0x20080000 size 0x300000
  memory RVCT9: RAM 0x0 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x80000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo510/hal/mcu/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group LVGL_imgbtn
    ../../../../../../third_party/LVGL/lvgl/src/widgets/imgbtn/: lv_imgbtn.c
  group LVGL_bar
    ../../../../../../third_party/LVGL/lvgl/src/widgets/bar/: lv_bar.c
  group LVGL_grid
    ../../../../../../third_party/LVGL/lvgl/src/layouts/grid/: lv_grid.c
  group LVGL_gif
    ../../../../../../third_party/LVGL/lvgl/src/libs/gif/: gifdec.c lv_gif.c
  group LVGL_spinner
    ../../../../../../third_party/LVGL/lvgl/src/widgets/spinner/: lv_spinner.c
  group LVGL_fsdrv
    ../../../../../../third_party/LVGL/lvgl/src/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
  group LVGL_mono
    ../../../../../../third_party/LVGL/lvgl/src/themes/mono/: lv_theme_mono.c
  group LVGL_tileview
    ../../../../../../third_party/LVGL/lvgl/src/widgets/tileview/: lv_tileview.c
  group LVGL_switch
    ../../../../../../third_party/LVGL/lvgl/src/widgets/switch/: lv_switch.c
  group LVGL_calendar
    ../../../../../../third_party/LVGL/lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
  group LVGL_led
    ../../../../../../third_party/LVGL/lvgl/src/widgets/led/: lv_led.c
  group LVGL_msgbox
    ../../../../../../third_party/LVGL/lvgl/src/widgets/msgbox/: lv_msgbox.c
  group LVGL_bmp
    ../../../../../../third_party/LVGL/lvgl/src/libs/bmp/: lv_bmp.c
  group LVGL_checkbox
    ../../../../../../third_party/LVGL/lvgl/src/widgets/checkbox/: lv_checkbox.c
  group LVGL_dropdown
    ../../../../../../third_party/LVGL/lvgl/src/widgets/dropdown/: lv_dropdown.c
  group LVGL_label
    ../../../../../../third_party/LVGL/lvgl/src/widgets/label/: lv_label.c
  group LVGL_slider
    ../../../../../../third_party/LVGL/lvgl/src/widgets/slider/: lv_slider.c
  group LVGL_font
    ../../../../../../third_party/LVGL/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
  group src
    ../src/: am_resources.c gui_task.c lvgl_watch_demo_simplified.c rtos.c
  group LVGL_flex
    ../../../../../../third_party/LVGL/lvgl/src/layouts/flex/: lv_flex.c
  group LVGL_png
    ../../../../../../third_party/LVGL/lvgl/src/libs/png/: lodepng.c lv_png.c
  group ThinkSi_apollo510_nemagfx
    ../../../../../../third_party/ThinkSi/config/apollo510_nemagfx/: nema_dc_hal.c nema_event.c nema_hal.c nema_utils.c
  group LVGL_span
    ../../../../../../third_party/LVGL/lvgl/src/widgets/span/: lv_span.c
  group LVGL_rlottie
    ../../../../../../third_party/LVGL/lvgl/src/libs/rlottie/: lv_rlottie.c
  group LVGL_draw
    ../../../../../../third_party/LVGL/lvgl/src/draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group LVGL_basic
    ../../../../../../third_party/LVGL/lvgl/src/themes/basic/: lv_theme_basic.c
  group LVGL_snapshot
    ../../../../../../third_party/LVGL/lvgl/src/others/snapshot/: lv_snapshot.c
  group FreeRTOSv10.5.1_AMapollo5
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/Keil6/AMapollo5/: port.c portasm.c port_stimer.c port_systick_stimer.c
  group LVGL_qrcode
    ../../../../../../third_party/LVGL/lvgl/src/libs/qrcode/: lv_qrcode.c qrcodegen.c
  group LVGL_win
    ../../../../../../third_party/LVGL/lvgl/src/widgets/win/: lv_win.c
  group LVGL_sjpg
    ../../../../../../third_party/LVGL/lvgl/src/libs/sjpg/: lv_sjpg.c tjpgd.c
  group LVGL_btnmatrix
    ../../../../../../third_party/LVGL/lvgl/src/widgets/btnmatrix/: lv_btnmatrix.c
  group LVGL_canvas
    ../../../../../../third_party/LVGL/lvgl/src/widgets/canvas/: lv_canvas.c
  group LVGL_spinbox
    ../../../../../../third_party/LVGL/lvgl/src/widgets/spinbox/: lv_spinbox.c
  group LVGL_misc
    ../../../../../../third_party/LVGL/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group LVGL_line
    ../../../../../../third_party/LVGL/lvgl/src/widgets/line/: lv_line.c
  group LVGL_textarea
    ../../../../../../third_party/LVGL/lvgl/src/widgets/textarea/: lv_textarea.c
  group LVGL_btn
    ../../../../../../third_party/LVGL/lvgl/src/widgets/btn/: lv_btn.c
  group LVGL_chart
    ../../../../../../third_party/LVGL/lvgl/src/widgets/chart/: lv_chart.c
  group LVGL_keyboard
    ../../../../../../third_party/LVGL/lvgl/src/widgets/keyboard/: lv_keyboard.c
  group LVGL_hal
    ../../../../../../third_party/LVGL/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group LVGL_roller
    ../../../../../../third_party/LVGL/lvgl/src/widgets/roller/: lv_roller.c
  group LVGL_core
    ../../../../../../third_party/LVGL/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group LVGL_tabview
    ../../../../../../third_party/LVGL/lvgl/src/widgets/tabview/: lv_tabview.c
  group LVGL_colorwheel
    ../../../../../../third_party/LVGL/lvgl/src/widgets/colorwheel/: lv_colorwheel.c
  group LVGL_default
    ../../../../../../third_party/LVGL/lvgl/src/themes/default/: lv_theme_default.c
  group LVGL_animimg
    ../../../../../../third_party/LVGL/lvgl/src/widgets/animimg/: lv_animimg.c
  group LVGL_objx_templ
    ../../../../../../third_party/LVGL/lvgl/src/widgets/objx_templ/: lv_objx_templ.c
  group LVGL_table
    ../../../../../../third_party/LVGL/lvgl/src/widgets/table/: lv_table.c
  group LVGL_img
    ../../../../../../third_party/LVGL/lvgl/src/widgets/img/: lv_img.c
  group LVGL_list
    ../../../../../../third_party/LVGL/lvgl/src/widgets/list/: lv_list.c
  group LVGL_freetype
    ../../../../../../third_party/LVGL/lvgl/src/libs/freetype/: lv_freetype.c
  group LVGL_meter
    ../../../../../../third_party/LVGL/lvgl/src/widgets/meter/: lv_meter.c
  group LVGL_arc
    ../../../../../../third_party/LVGL/lvgl/src/widgets/arc/: lv_arc.c
  group devices
    ../../../../../../devices/: am_devices_display_generic.c
  group LVGL_gpu
    ../../../../../../third_party/LVGL/lvgl/src/gpu/: lv_gpu_ambiq_nema.c
  group LVGL_ambiq_support
    ../../../../../../third_party/LVGL/ambiq_support/: display_task_cpu_only.c display_task_fake.c display_task_one_and_partial_fb.c display_task_one_fb.c display_task_two_fb.c lv_ambiq_decoder.c lv_ambiq_font_align.c lv_ambiq_fs.c lv_ambiq_misc.c lv_ambiq_nema_hal.c lv_ambiq_touch.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_id.c am_util_stdio.c
  group FreeRTOSv10.5.1_Source
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/: event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOSv10.5.1_MemMang
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/MemMang/: heap_4.c
  group keil6
    ../keil6/: startup_keil6.c
  group lib
    ../../../../../../mcu/apollo510/hal/mcu/keil6/bin/: libam_hal.lib
    ../../../../bsp/keil6/bin/: libam_bsp.lib
    ../../../../../../CMSIS/ARM/Lib/ARM/DSP_LIB_CM55/: arm_cortexM55f_math.lib
    ../../../../../../third_party/LVGL/ambiq_support/gpu_lib_apollo5/keil6/bin/: lvgl_ambiq_porting.lib
    ../../../../../../third_party/ThinkSi/config/apollo510_nemagfx/keil6/bin/: lib_nema_apollo510_nemagfx.lib
software components: Device:Startup 1.1.0
