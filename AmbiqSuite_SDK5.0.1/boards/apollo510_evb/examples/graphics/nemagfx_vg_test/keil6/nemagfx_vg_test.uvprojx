# Keil uVision project nemagfx_vg_test.uvprojx, settings and files
target nemagfx_vg_test (6220000::V6.22::ARMCLANG)
  device: AP510NFA-CBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.5.0
  cpu: IRAM(0x00000000,0x00040000) IRAM2(0x20000000,0x00080000) IROM(0x00400000,0x00400000) XRAM(0x20080000,0x00300000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP CLOCK(12000000) ELITTLE
  output: nemagfx_vg_test
  AfterMake: fromelf --bin --output bin\nemagfx_vg_test.bin bin\nemagfx_vg_test.axf
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AM_PART_APOLLO510 NEMA_PLATFORM=apollo510_nemagfx BAREMETAL apollo510_evb NEMA_CUSTOM_MALLOC_INCLUDE=\"nemagfx_buffer_customize.h\" NEMA_USE_CUSTOM_MALLOC AM_PACKAGE_BGA AM_UTIL_FAULTISR_PRINT NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib keil6
  c include: ../../../../../../third_party/ThinkSi/NemaGFX_SDK/common/mem;../../../../../../third_party/ThinkSi/NemaGFX_SDK/NemaGFX;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaGFX;../../../../../../third_party/ThinkSi/NemaGFX_SDK/NemaGFX/Nema;../../../../../../CMSIS/ARM/Include;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaVG;../../../../../../mcu/apollo510;../../../../../../mcu/apollo510/hal;../../../../../../devices;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/common;../../../../../..;../../../../bsp;../src;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaDC;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../third_party/ThinkSi/NemaGFX_SDK/NemaDC;../../../../../../third_party/ThinkSi/config/apollo510_nemagfx;../../../../../../utils
  memory RVCT4: ROM 0x400000 size 0x400000
  memory RVCT6: RAM 0x20080000 size 0x300000
  memory RVCT9: RAM 0x0 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x80000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo510/hal/mcu/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group masking_example
    ../src/masking_example/: masking_example.c
  group paint_example
    ../src/paint_example/: paint_example.c
  group text_transformation
    ../src/text_transformation/: text_transformation.c
  group render_raw_ttf
    ../src/render_raw_ttf/: render_raw_ttf.c
  group tsvg_measure
    ../src/tsvg_measure/: tsvg_measure.c
  group paint_lut_example
    ../src/paint_lut_example/: paint_lut_example.c
  group raster_arc
    ../src/raster_arc/: raster_arc.c
  group joins_caps
    ../src/joins_caps/: joins_caps.c
  group tsvg_benchmark
    ../src/tsvg_benchmark/: tsvg_benchmark.c
  group src
    ../src/: am_resources.c display.c nemagfx_buffer_customize.c nemagfx_vg_test.c
  group render_vg_font
    ../src/render_vg_font/: DejaVuSans_ttf_kern.c render_vg_font.c
  group dash
    ../src/dash/: dash_example.c
  group shapes
    ../src/shapes/: shapes.c
  group tsvg_render_example
    ../src/tsvg_render_example/: Arial_ttf.c tsvg_render_example.c
  group ThinkSi_apollo510_nemagfx
    ../../../../../../third_party/ThinkSi/config/apollo510_nemagfx/: nema_dc_hal.c nema_event.c nema_hal.c nema_utils.c
  group devices
    ../../../../../../devices/: am_devices_dc_dsi_raydium.c am_devices_dc_xspi_raydium.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_pmu.c am_util_stdio.c
  group keil6
    ../keil6/: startup_keil6.c
  group lib
    ../../../../bsp/keil6/bin/: libam_bsp.lib
    ../../../../../../mcu/apollo510/hal/mcu/keil6/bin/: libam_hal.lib
    ../../../../../../third_party/ThinkSi/config/apollo510_nemagfx/keil6/bin/: lib_nema_apollo510_nemagfx.lib
software components: Device:Startup 1.1.0
