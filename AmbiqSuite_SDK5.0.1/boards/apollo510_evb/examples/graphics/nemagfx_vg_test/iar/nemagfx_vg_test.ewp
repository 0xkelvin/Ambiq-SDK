# IAR project nemagfx_vg_test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AP510NFA-CBR AmbiqMicro AP510NFA-CBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 64
  General.FPU2: 7
  ICCARM.CCDefines: iar; AM_PART_APOLLO510; NEMA_PLATFORM=apollo510_nemagfx; BAREMETAL; apollo510_evb; NEMA_CUSTOM_MALLOC_INCLUDE="nemagfx_buffer_customize.h"; NEMA_USE_CUSTOM_MALLOC; AM_PACKAGE_BGA; AM_UTIL_FAULTISR_PRINT; NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK; LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\common\mem; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\NemaGFX; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\NemaGFX; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\NemaGFX\Nema; ..\..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\NemaVG; ..\..\..\..\..\..\mcu\apollo510; ..\..\..\..\..\..\mcu\apollo510\hal; ..\..\..\..\..\..\devices; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\common; ..\..\..\..\..\..; ..\..\..\..\bsp; ..\src; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\NemaDC; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\NemaDC; ..\..\..\..\..\..\third_party\ThinkSi\config\apollo510_nemagfx; ..\..\..\..\..\..\utils
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: nemagfx_vg_test.bin
  ILINK.IlinkOutputFile: nemagfx_vg_test.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\third_party\ThinkSi\config\apollo510_nemagfx\iar\bin\lib_nema_apollo510_nemagfx.a; ..\..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\..\mcu\apollo510\hal\mcu\iar\bin\libam_hal.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.FPU2: 1
  ICCARM.CCDefines: NDEBUG; iar; AM_PART_APOLLO510; NEMA_PLATFORM=apollo510_nemagfx; BAREMETAL; apollo510_evb; NEMA_CUSTOM_MALLOC_INCLUDE="nemagfx_buffer_customize.h"; NEMA_USE_CUSTOM_MALLOC; AM_PACKAGE_BGA; AM_UTIL_FAULTISR_PRINT; NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK; LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib
  group (top)
    ../src/masking_example/: masking_example.c
    ../src/paint_example/: paint_example.c
    ../src/text_transformation/: text_transformation.c
    ../src/render_raw_ttf/: render_raw_ttf.c
    ../src/tsvg_measure/: tsvg_measure.c
    ../src/paint_lut_example/: paint_lut_example.c
    ../src/raster_arc/: raster_arc.c
    ../src/joins_caps/: joins_caps.c
    ../src/tsvg_benchmark/: tsvg_benchmark.c
    ../src/: am_resources.c display.c nemagfx_buffer_customize.c nemagfx_vg_test.c
    ../src/render_vg_font/: DejaVuSans_ttf_kern.c render_vg_font.c
    ../src/dash/: dash_example.c
    ../src/shapes/: shapes.c
    ../src/tsvg_render_example/: Arial_ttf.c tsvg_render_example.c
    ../../../../../../third_party/ThinkSi/config/apollo510_nemagfx/: nema_dc_hal.c nema_event.c nema_hal.c nema_utils.c
    ../../../../../../devices/: am_devices_dc_dsi_raydium.c am_devices_dc_xspi_raydium.c
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_pmu.c am_util_stdio.c
    ./: startup_iar.c
