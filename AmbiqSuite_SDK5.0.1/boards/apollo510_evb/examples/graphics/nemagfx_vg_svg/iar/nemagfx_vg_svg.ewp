# IAR project nemagfx_vg_svg.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AP510NFA-CBR AmbiqMicro AP510NFA-CBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 64
  General.FPU2: 7
  ICCARM.CCDefines: iar; apollo510_evb; AM_FREERTOS; NEMA_PLATFORM=apollo510_nemagfx; MSPI_PSRAM_TIMING_CHECK; NEMA_USE_CUSTOM_MALLOC; NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK; AM_PACKAGE_BGA; GPU_WORK_TIME_PRINT; NON_CACHEABLE_CL_RB_HEAP=1; AM_PART_APOLLO510; AM_UTIL_FAULTISR_PRINT; LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib; NEMA_CUSTOM_MALLOC_INCLUDE="nemagfx_buffer_customize.h"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\third_party\FreeRTOSv10.5.1\Source\portable\IAR\AMapollo5; ..\..\..\..\..\..\devices; ..\..\..\..\..\..\utils; ..\..\..\..\..\..\third_party\FreeRTOSv10.5.1\Source\include; ..\..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\NemaGFX; ..\..\..\..\bsp; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\NemaDC; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\common\mem; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\NemaGFX\Nema; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\common; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\NemaGFX; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\NemaDC; ..\src; ..\..\..\..\..\..\mcu\apollo510; ..\..\..\..\..\..\mcu\apollo510\hal; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\NemaVG; ..\..\..\..\..\..; ..\..\..\..\..\..\third_party\ThinkSi\config\apollo510_nemagfx
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: nemagfx_vg_svg.bin
  ILINK.IlinkOutputFile: nemagfx_vg_svg.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\..\third_party\ThinkSi\config\apollo510_nemagfx\iar\bin\lib_nema_apollo510_nemagfx.a; ..\..\..\..\..\..\mcu\apollo510\hal\mcu\iar\bin\libam_hal.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.FPU2: 1
  ICCARM.CCDefines: NDEBUG; iar; apollo510_evb; AM_FREERTOS; NEMA_PLATFORM=apollo510_nemagfx; MSPI_PSRAM_TIMING_CHECK; NEMA_USE_CUSTOM_MALLOC; NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK; AM_PACKAGE_BGA; GPU_WORK_TIME_PRINT; NON_CACHEABLE_CL_RB_HEAP=1; AM_PART_APOLLO510; AM_UTIL_FAULTISR_PRINT; LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib; NEMA_CUSTOM_MALLOC_INCLUDE="nemagfx_buffer_customize.h"
  group (top)
    ../src/: am_resources.c display_task.c gui_task.c nemagfx_buffer_customize.c nemagfx_vg_svg.c render_task.c rtos.c
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/IAR/AMapollo5/: port.c portasm.s port_stimer.c port_systick_stimer.c
    ../../../../../../third_party/ThinkSi/config/apollo510_nemagfx/: nema_dc_hal.c nema_event.c nema_hal.c nema_utils.c
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
    ../../../../../../devices/: am_devices_display_generic.c
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/MemMang/: heap_4.c
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ./: startup_iar.c
