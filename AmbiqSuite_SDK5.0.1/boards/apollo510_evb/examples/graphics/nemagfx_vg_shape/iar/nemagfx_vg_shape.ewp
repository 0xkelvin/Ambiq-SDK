# IAR project nemagfx_vg_shape.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AP510NFA-CBR AmbiqMicro AP510NFA-CBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 64
  General.FPU2: 7
  ICCARM.CCDefines: iar; AM_PACKAGE_BGA; GPU_WORK_TIME_PRINT; LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib; NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK; NEMA_PLATFORM=apollo510_nemagfx; AM_PART_APOLLO510; AM_UTIL_FAULTISR_PRINT; AM_FREERTOS; apollo510_evb
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\third_party\ThinkSi\config\apollo510_nemagfx; ..\..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\common; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\..\mcu\apollo510; ..\..\..\..\bsp; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\NemaGFX; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\NemaDC; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\NemaDC; ..\src; ..\..\..\..\..\..\utils; ..\..\..\..\..\..\third_party\FreeRTOSv10.5.1\Source\portable\IAR\AMapollo5; ..\..\..\..\..\..\third_party\FreeRTOSv10.5.1\Source\include; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\common\mem; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\NemaVG; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\NemaGFX\Nema; ..\..\..\..\..\..\mcu\apollo510\hal; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\NemaGFX; ..\..\..\..\..\..\devices; ..\..\..\..\..\..
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: nemagfx_vg_shape.bin
  ILINK.IlinkOutputFile: nemagfx_vg_shape.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\..\third_party\ThinkSi\config\apollo510_nemagfx\iar\bin\lib_nema_apollo510_nemagfx.a; ..\..\..\..\..\..\mcu\apollo510\hal\mcu\iar\bin\libam_hal.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.FPU2: 1
  ICCARM.CCDefines: NDEBUG; iar; AM_PACKAGE_BGA; GPU_WORK_TIME_PRINT; LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib; NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK; NEMA_PLATFORM=apollo510_nemagfx; AM_PART_APOLLO510; AM_UTIL_FAULTISR_PRINT; AM_FREERTOS; apollo510_evb
  group (top)
    ../src/: am_resources.c display_task.c gui_task.c nemagfx_vg_shape.c render_task.c rtos.c
    ../../../../../../third_party/ThinkSi/config/apollo510_nemagfx/: nema_dc_hal.c nema_event.c nema_hal.c nema_utils.c
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/IAR/AMapollo5/: port.c portasm.s port_stimer.c port_systick_stimer.c
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/MemMang/: heap_4.c
    ../../../../../../devices/: am_devices_dc_dsi_raydium.c am_devices_dc_xspi_raydium.c
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ./: startup_iar.c
