# Keil uVision project nemadc_4layers.uvprojx, settings and files
target nemadc_4layers (6220000::V6.22::ARMCLANG)
  device: AP510NFA-CBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.5.0
  cpu: IRAM(0x00000000,0x00040000) IRAM2(0x20000000,0x00080000) IROM(0x00400000,0x00400000) XRAM(0x20080000,0x00300000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP CLOCK(12000000) ELITTLE
  output: nemadc_4layers
  AfterMake: fromelf --bin --output bin\nemadc_4layers.bin bin\nemadc_4layers.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK AM_PACKAGE_BGA NEMA_PLATFORM=apollo510_nemagfx LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib AM_PART_APOLLO510 BAREMETAL keil6
  c include: ../src;../../../../../../utils;../../../../../../third_party/ThinkSi/NemaGFX_SDK/NemaGFX/Nema;../../../../bsp;../../../../../../devices;../../../../../../third_party/ThinkSi/NemaGFX_SDK/NemaDC;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaGFX;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../..;../../../../../../third_party/ThinkSi/NemaGFX_SDK/common/mem;../../../../../../mcu/apollo510/hal/mcu;../../../../../../third_party/ThinkSi/config/apollo510_nemagfx;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/common;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaDC;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaVG;../../../../../../CMSIS/ARM/Include;../../../../../../mcu/apollo510;../../../../../../mcu/apollo510/hal;../../../../../../third_party/ThinkSi/NemaGFX_SDK/NemaGFX
  memory RVCT4: ROM 0x400000 size 0x400000
  memory RVCT6: RAM 0x20080000 size 0x300000
  memory RVCT9: RAM 0x0 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x80000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo510/hal/mcu/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group src
    ../src/: am_resources.c nemadc_4layers.c
  group ThinkSi_apollo510_nemagfx
    ../../../../../../third_party/ThinkSi/config/apollo510_nemagfx/: nema_dc_hal.c nema_event.c nema_hal.c nema_utils.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_stdio.c
  group devices
    ../../../../../../devices/: am_devices_dc_dsi_raydium.c am_devices_dc_xspi_raydium.c
  group keil6
    ../keil6/: startup_keil6.c
  group lib
    ../../../../../../mcu/apollo510/hal/mcu/keil6/bin/: libam_hal.lib
    ../../../../../../third_party/ThinkSi/config/apollo510_nemagfx/keil6/bin/: lib_nema_apollo510_nemagfx.lib
    ../../../../bsp/keil6/bin/: libam_bsp.lib
software components: Device:Startup 1.1.0
