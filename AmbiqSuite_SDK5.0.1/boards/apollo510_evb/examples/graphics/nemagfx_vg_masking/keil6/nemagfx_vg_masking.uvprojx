# Keil uVision project nemagfx_vg_masking.uvprojx, settings and files
target nemagfx_vg_masking (6220000::V6.22::ARMCLANG)
  device: AP510NFA-CBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.5.0
  cpu: IRAM(0x00000000,0x00040000) IRAM2(0x20000000,0x00080000) IROM(0x00400000,0x00400000) XRAM(0x20080000,0x00300000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP CLOCK(12000000) ELITTLE
  output: nemagfx_vg_masking
  AfterMake: fromelf --bin --output bin\nemagfx_vg_masking.bin bin\nemagfx_vg_masking.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: apollo510_evb GPU_WORK_TIME_PRINT AM_UTIL_FAULTISR_PRINT AM_PACKAGE_BGA AM_PART_APOLLO510 LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK NEMA_PLATFORM=apollo510_nemagfx AM_FREERTOS keil6
  c include: ../../../../../..;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaGFX;../../../../../../third_party/ThinkSi/NemaGFX_SDK/common/mem;../../../../../../third_party/ThinkSi/NemaGFX_SDK/NemaGFX/Nema;../../../../../../third_party/ThinkSi/config/apollo510_nemagfx;../../../../../../third_party/FreeRTOSv10.5.1/Source/include;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/common;../../../../../../utils;../src;../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/Keil6/AMapollo5;../../../../../../mcu/apollo510/hal;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaDC;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaVG;../../../../../../mcu/apollo510;../../../../bsp;../../../../../../third_party/ThinkSi/NemaGFX_SDK/NemaDC;../../../../../../devices;../../../../../../CMSIS/ARM/Include;../../../../../../third_party/ThinkSi/NemaGFX_SDK/NemaGFX
  memory RVCT4: ROM 0x400000 size 0x400000
  memory RVCT6: RAM 0x20080000 size 0x300000
  memory RVCT9: RAM 0x0 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x80000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo510/hal/mcu/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group src
    ../src/: am_resources.c display_task.c gui_task.c nemagfx_vg_masking.c render_task.c rtos.c
  group FreeRTOSv10.5.1_AMapollo5
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/Keil6/AMapollo5/: port.c portasm.c port_stimer.c port_systick_stimer.c
  group ThinkSi_apollo510_nemagfx
    ../../../../../../third_party/ThinkSi/config/apollo510_nemagfx/: nema_dc_hal.c nema_event.c nema_hal.c nema_utils.c
  group devices
    ../../../../../../devices/: am_devices_dc_dsi_raydium.c am_devices_dc_xspi_raydium.c
  group FreeRTOSv10.5.1_MemMang
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/MemMang/: heap_4.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_id.c am_util_stdio.c
  group FreeRTOSv10.5.1_Source
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/: event_groups.c list.c queue.c tasks.c timers.c
  group keil6
    ../keil6/: startup_keil6.c
  group lib
    ../../../../../../third_party/ThinkSi/config/apollo510_nemagfx/keil6/bin/: lib_nema_apollo510_nemagfx.lib
    ../../../../../../mcu/apollo510/hal/mcu/keil6/bin/: libam_hal.lib
    ../../../../bsp/keil6/bin/: libam_bsp.lib
software components: Device:Startup 1.1.0
