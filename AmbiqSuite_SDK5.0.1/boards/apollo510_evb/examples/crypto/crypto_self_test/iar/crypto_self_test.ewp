# IAR project crypto_self_test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AP510NFA-CBR AmbiqMicro AP510NFA-CBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 64
  General.FPU2: 7
  ICCARM.CCDefines: iar; AM_PART_APOLLO510; CC_IOT; AM_PACKAGE_BGA; AM_UTIL_FAULTISR_PRINT
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\third_party\crypto\shared\include\pal; ..\..\..\..\..\..\utils; ..\..\..\..\..\..\third_party\crypto\mbedtls\include\mbedtls; ..\..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\..\third_party\crypto\host\include; ..\..\..\..\..\..; ..\src; ..\..\..\..\..\..\third_party\crypto\shared\include\pal\no_os; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\bsp; ..\..\..\..\..\..\mcu\apollo510; ..\..\..\..\..\..\third_party\crypto\mbedtls\include; ..\..\..\..\..\..\devices
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: crypto_self_test.bin
  ILINK.IlinkOutputFile: crypto_self_test.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\mcu\apollo510\hal\mcu\iar\bin\libam_hal.a; ..\..\..\..\..\..\third_party\crypto\mbedtls\library\libmbedcrypto-m55.a; ..\..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\..\third_party\crypto\host\lib\libpal_no_os-m55.a; ..\..\..\..\..\..\third_party\crypto\host\lib\libcc_312-m55.a; ..\..\..\..\..\..\third_party\crypto\mbedtls\library\libmbedx509-m55.a; ..\..\..\..\..\..\third_party\crypto\mbedtls\library\libmbedtls-m55.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.FPU2: 1
  ICCARM.CCDefines: NDEBUG; iar; AM_PART_APOLLO510; CC_IOT; AM_PACKAGE_BGA; AM_UTIL_FAULTISR_PRINT
  group (top)
    ../src/: am_resources.c crypto_self_test.c
    ../../../../../../utils/: am_util_crypto.c am_util_delay.c am_util_faultisr.c am_util_stdio.c
    ./: startup_iar.c
