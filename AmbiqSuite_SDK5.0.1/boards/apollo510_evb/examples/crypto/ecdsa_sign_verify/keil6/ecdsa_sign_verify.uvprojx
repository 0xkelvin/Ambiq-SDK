# Keil uVision project ecdsa_sign_verify.uvprojx, settings and files
target ecdsa_sign_verify (6220000::V6.22::ARMCLANG)
  device: AP510NFA-CBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.5.0
  cpu: IRAM(0x00000000,0x00040000) IRAM2(0x20000000,0x00080000) IROM(0x00400000,0x00400000) XRAM(0x20080000,0x00300000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP CLOCK(12000000) ELITTLE
  output: ecdsa_sign_verify
  AfterMake: fromelf --bin --output bin\ecdsa_sign_verify.bin bin\ecdsa_sign_verify.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AM_UTIL_FAULTISR_PRINT AM_HAL_SKIP_NO_MVE_WARNING AM_PART_APOLLO510 CC_IOT AM_PACKAGE_BGA keil6
  c include: ../../../../../../third_party/crypto/mbedtls/include;../../../../bsp;../../../../../../third_party/crypto/shared/include/pal;../../../../../../third_party/crypto/host/include;../src;../../../../../../utils;../../../../../../CMSIS/ARM/Include;../../../../../../mcu/apollo510;../../../../../..;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../devices;../../../../../../third_party/crypto/shared/include/pal/no_os
  memory RVCT4: ROM 0x400000 size 0x400000
  memory RVCT6: RAM 0x20080000 size 0x300000
  memory RVCT9: RAM 0x0 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x80000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo510/hal/mcu/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group src
    ../src/: am_resources.c ecdsa_sign_verify.c
  group utils
    ../../../../../../utils/: am_util_crypto.c am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group keil6
    ../keil6/: startup_keil6.c
  group lib
    ../../../../../../mcu/apollo510/hal/mcu/keil6/bin/: libam_hal.lib
    ../../../../../../third_party/crypto/host/lib/: libpal_no_os-m55.lib libcc_312-m55.lib
    ../../../../bsp/keil6/bin/: libam_bsp.lib
    ../../../../../../third_party/crypto/mbedtls/library/: cryptombedtls-m55.lib
software components: Device:Startup 1.1.0
