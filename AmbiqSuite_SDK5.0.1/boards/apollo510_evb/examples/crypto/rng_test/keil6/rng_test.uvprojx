# Keil uVision project rng_test.uvprojx, settings and files
target rng_test (6220000::V6.22::ARMCLANG)
  device: AP510NFA-CBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.5.0
  cpu: IRAM(0x00000000,0x00040000) IRAM2(0x20000000,0x00080000) IROM(0x00400000,0x00400000) XRAM(0x20080000,0x00300000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP CLOCK(12000000) ELITTLE
  output: rng_test
  AfterMake: fromelf --bin --output bin\rng_test.bin bin\rng_test.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AM_PACKAGE_BGA CC_IOT AM_UTIL_FAULTISR_PRINT AM_PART_APOLLO510 keil6
  c include: ../../../../../..;../../../../../../third_party/crypto/host/include;../../../../../../mcu/apollo510;../../../../../../utils;../../../../../../third_party/crypto/shared/include/pal;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../devices;../../../../../../CMSIS/ARM/Include;../../../../../../third_party/crypto/mbedtls/include;../src;../../../../../../third_party/crypto/shared/include/pal/no_os;../../../../bsp
  memory RVCT4: ROM 0x400000 size 0x400000
  memory RVCT6: RAM 0x20080000 size 0x300000
  memory RVCT9: RAM 0x0 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x80000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo510/hal/mcu/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group src
    ../src/: am_resources.c rng_test.c
  group utils
    ../../../../../../utils/: am_util_crypto.c am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group keil6
    ../keil6/: startup_keil6.c
  group lib
    ../../../../../../third_party/crypto/mbedtls/library/: cryptombedtls-m55.lib
    ../../../../bsp/keil6/bin/: libam_bsp.lib
    ../../../../../../third_party/crypto/host/lib/: libcc_312-m55.lib libpal_no_os-m55.lib
    ../../../../../../mcu/apollo510/hal/mcu/keil6/bin/: libam_hal.lib
software components: Device:Startup 1.1.0
