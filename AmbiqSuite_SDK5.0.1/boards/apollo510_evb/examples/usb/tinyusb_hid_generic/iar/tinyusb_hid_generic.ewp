# IAR project tinyusb_hid_generic.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AP510NFA-CBR AmbiqMicro AP510NFA-CBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 64
  General.FPU2: 7
  ICCARM.CCDefines: iar; AM_PACKAGE_BGA; AM_PART_APOLLO510; apollo510_evb; CFG_TUSB_MCU=OPT_MCU_APOLLO5; BOARD_DEVICE_RHPORT_SPEED=OPT_MODE_HIGH_SPEED; CFG_TUSB_DEBUG=0; AM_CFG_USB_DMA_MODE_1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\devices; ..\..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\..\mcu\apollo510; ..\..\..\..\..\..\mcu\apollo510\hal; ..\..\..\..\..\..\third_party\tinyusb\source\src; ..\..\..\..\..\..\third_party\tinyusb\source\src\common; ..\..\..\..\bsp; ..\..\..\..\..\..\third_party\tinyusb\source\src\class\hid; ..\src; ..\..\..\..\..\..\third_party\tinyusb\source\src\osal; ..\..\..\..\..\..\utils; ..\..\..\..\..\..; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: tinyusb_hid_generic.bin
  ILINK.IlinkOutputFile: tinyusb_hid_generic.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\mcu\apollo510\hal\mcu\iar\bin\libam_hal.a; ..\..\..\..\bsp\iar\bin\libam_bsp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.FPU2: 1
  ICCARM.CCDefines: NDEBUG; iar; AM_PACKAGE_BGA; AM_PART_APOLLO510; apollo510_evb; CFG_TUSB_MCU=OPT_MCU_APOLLO5; BOARD_DEVICE_RHPORT_SPEED=OPT_MODE_HIGH_SPEED; CFG_TUSB_DEBUG=0; AM_CFG_USB_DMA_MODE_1
  group (top)
    ../../../../../../third_party/tinyusb/ambiq_port/apollo5/: dcd_apollo5.c
    ../src/: am_resources.c apollo5_board.c tinyusb_hid_generic.c usb_descriptors.c
    ../../../../../../third_party/tinyusb/source/src/device/: usbd.c usbd_control.c
    ../../../../../../third_party/tinyusb/source/src/: tusb.c
    ../../../../../../third_party/tinyusb/source/src/common/: tusb_fifo.c
    ../../../../../../utils/: am_util_delay.c am_util_id.c am_util_stdio.c
    ../../../../../../third_party/tinyusb/source/src/class/hid/: hid_device.c
    ./: startup_iar.c
