# IAR project tinyusb_cdc_msc_emmc.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AP510NFA-CBR AmbiqMicro AP510NFA-CBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 64
  General.FPU2: 7
  ICCARM.CCDefines: iar; AM_CFG_USB_EP5_IN_DBUF_ENABLE; AM_CFG_USB_DMA_MODE_1; CFG_TUSB_MCU=OPT_MCU_APOLLO5; AM_CDC_USE_APP_BUF; BOARD_DEVICE_RHPORT_SPEED=OPT_MODE_HIGH_SPEED; AM_CFG_USB_EP4_OUT_DBUF_ENABLE; apollo510_evb; AM_PACKAGE_BGA; AM_PART_APOLLO510; CFG_TUSB_DEBUG=0
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\third_party\tinyusb\source\src\common; ..\..\..\..\..\..\mcu\apollo510\hal; ..\..\..\..\bsp; ..\..\..\..\..\..\third_party\tinyusb\source\src; ..\..\..\..\..\..\third_party\tinyusb\source\src\osal; ..\..\..\..\..\..\mcu\apollo510; ..\..\..\..\..\..; ..\..\..\..\..\..\third_party\tinyusb\source\src\class\msc; ..\..\..\..\..\..\utils; ..\src; ..\..\..\..\..\..\third_party\tinyusb\source\src\class\cdc; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\..\devices; ..\..\..\..\..\..\CMSIS\ARM\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: tinyusb_cdc_msc_emmc.bin
  ILINK.IlinkOutputFile: tinyusb_cdc_msc_emmc.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\..\mcu\apollo510\hal\mcu\iar\bin\libam_hal.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.FPU2: 1
  ICCARM.CCDefines: NDEBUG; iar; AM_CFG_USB_EP5_IN_DBUF_ENABLE; AM_CFG_USB_DMA_MODE_1; CFG_TUSB_MCU=OPT_MCU_APOLLO5; AM_CDC_USE_APP_BUF; BOARD_DEVICE_RHPORT_SPEED=OPT_MODE_HIGH_SPEED; AM_CFG_USB_EP4_OUT_DBUF_ENABLE; apollo510_evb; AM_PACKAGE_BGA; AM_PART_APOLLO510; CFG_TUSB_DEBUG=0
  group (top)
    ../../../../../../third_party/tinyusb/source/src/common/: tusb_fifo.c
    ../../../../../../third_party/tinyusb/source/src/device/: usbd.c usbd_control.c
    ../src/: am_resources.c apollo5_board.c msc_emmc_disk.c tinyusb_cdc_msc_emmc.c usb_descriptors.c
    ../../../../../../third_party/tinyusb/ambiq_port/apollo5/: dcd_apollo5.c
    ../../../../../../third_party/tinyusb/source/src/: tusb.c
    ../../../../../../third_party/tinyusb/source/src/class/msc/: msc_device.c
    ../../../../../../utils/: am_util_delay.c am_util_id.c am_util_stdio.c
    ../../../../../../third_party/tinyusb/source/src/class/cdc/: cdc_device.c
    ./: startup_iar.c
